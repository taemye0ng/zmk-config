## boards/shields/hands_free_mouse/Kconfig.shield
```kconfig
config SHIELD_HANDS_FREE_MOUSE
    def_bool $(shields_list_contains,hands_free_mouse)
```
